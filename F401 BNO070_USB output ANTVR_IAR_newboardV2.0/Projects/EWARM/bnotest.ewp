# IAR project bnotest.ewp, settings and files
configuration bnotest Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xB ST STM32F401xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F401xE; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\Libraries\STM32F4xx_HAL_Driver\Inc; ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\User; ..\..\bsp; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\User
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: bnotest Configuration.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/bno-hostif
    ../../bsp/: sensorhub.c sensorhub_hid.c
    ../../../../src/: sensorhub.h sensorhub_hid.h sensorhub_platform.h
  group Application/CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xe.s
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Application/STM32F4xx_HAL_Driver
    ../../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_usb.c
  group Application/User
    ../../User/: adc.c freertos.c key.c main.c oula.c stm32f4xx_hal_msp.c stm32f4xx_it.c stmflash.c usb_device.c usbd_conf.c usbd_desc.c
    ../../bsp/: bno070.c i2c_master_transfer.c print.c
    ../../Inc/: i2c_master_transfer.h
  group USB DEVICE
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
